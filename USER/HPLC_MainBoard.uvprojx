# Keil uVision project HPLC_MainBoard.uvprojx, settings and files
target HPLC_Collector_Mini (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HPLC_COLLECTOR_Mini +hex
  AfterMake: ..\Hex2Bin.bat
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\Logic;..\STM32F10x_FWLib\src;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\SENSOR;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\COM_DRIVE;..\Utils;..\SimPLC
  memory RVCT4: ROM 0x8003000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md_vl.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group COM_DRIVE
    ../COM_DRIVE/: ComDriver.c ComProcess.c ComQueue.c ComUart.c ComLan.c ComProcess2.c ComDriver2.c
  group Utils
    ../Utils/: Queue.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/: IO.c W5500.c wdg.c Key.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Logic
    ../Logic/: miscellaneous.c management.c Project.c
  group SimPLC
    ../SimPLC/: simplc_io.c
  group README
    ../: Version.txt
